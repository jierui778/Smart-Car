# Keil uVision project RT1064_CAR.uvprojx, settings and files
target RT1064_CAR (6190000::V6.19::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.17.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1064_CAR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, USB_STACK_BM, DEBUG, MCUXPRESSO_SDK, SD_ENABLED
  c include: ..\..\Libraries\sdk\startup\mdk;..\..\libraries\sdk\deceive;..\..\libraries\sdk\drives;..\..\libraries\sdk\xip;..\..\libraries\sdk\utilities;..\..\libraries\sdk\utilities\debug_console;..\..\libraries\sdk\utilities\str;..\..\libraries\sdk\cmsis_drivers;..\..\libraries\sdk\CMSIS\Include;..\..\libraries\sdk\CMSIS\Driver\Include;..\..\libraries\sdk\components\lists;..\..\libraries\sdk\components\osa;..\..\libraries\sdk\components\serial_manager;..\..\libraries\sdk\components\uart;..\..\libraries\sdk\board;..\..\libraries\components\fatfs\source;..\..\libraries\components\fatfs\source\fsl_sd_disk;..\..\libraries\components\sdmmc;..\..\libraries\components\sdmmc\common;..\..\libraries\components\sdmmc\host\usdhc;..\..\libraries\components\sdmmc\osa;..\..\libraries\components\sdmmc\sd;..\..\libraries\components\usb\device;..\..\libraries\components\usb\include;..\..\libraries\components\usb\phy;..\..\libraries\components\usb\usb_cdc_adapter;..\..\libraries\zf_common;..\..\libraries\zf_driver;..\..\libraries\zf_device;..\USER\inc;..\HARDWARE
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\scf\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler
  group user_c
    ../USER/src/: isr.c main.c
  group user_h
    ../USER/inc/: isr.h
  group hardware
    ../HARDWARE/: servo.c servo.h motor.c motor.h encoder.c encoder.h camera.h camera.c image.c image.h buzzer.h buzzer.c schedule.c schedule.h display.h display.c mymath.c mymath.h pid.c pid.h control.c control.h filter.c filter.h cross.c cross.h
  group zf_common
    ../../Libraries/zf_common/: zf_common_clock.c zf_common_debug.c zf_common_fifo.c zf_common_font.c zf_common_function.c zf_common_interrupt.c zf_common_vector.c zf_common_clock.h zf_common_debug.h zf_common_fifo.h zf_common_font.h zf_common_function.h zf_common_headfile.h zf_common_interrupt.h zf_common_typedef.h zf_common_vector.h
  group zf-device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_bluetooth_ch9141.c zf_device_camera.c zf_device_detector.c zf_device_dl1a.c zf_device_dl1b.c zf_device_gps_tau1201.c zf_device_icm20602.c zf_device_imu660ra.c zf_device_imu963ra.c zf_device_ips114.c zf_device_ips200.c zf_device_key.c zf_device_mpu6050.c zf_device_mt9v03x.c zf_device_mt9v03x_flexio.c zf_device_oled.c zf_device_ov7725.c zf_device_scc8660.c zf_device_scc8660_flexio.c zf_device_tft180.c zf_device_tsl1401.c zf_device_type.c zf_device_virtual_oscilloscope.c zf_device_wifi_spi.c zf_device_wifi_uart.c zf_device_wireless_uart.c zf_device_config.lib
  group zf-driver
    ../../libraries/zf_driver/: zf_driver_csi.c zf_driver_delay.c zf_driver_encoder.c zf_driver_exti.c zf_driver_flash.c zf_driver_flexio_csi.c zf_driver_gpio.c zf_driver_iic.c zf_driver_pit.c zf_driver_adc.c zf_driver_pwm.c zf_driver_romapi.c zf_driver_sdio.c zf_driver_soft_iic.c zf_driver_soft_spi.c zf_driver_spi.c zf_driver_timer.c zf_driver_uart.c zf_driver_usb_cdc.c
  group sdk_driver
    ../../Libraries/sdk/drives/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_common_arm.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_flexio.c fsl_flexio_camera.c fsl_flexio_camera_edma.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_mculcd.c fsl_flexio_mculcd_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexram_allocate.c fsl_flexspi.c fsl_flexspi_edma.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ocotp.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_romapi.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_tempmon.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c fsl_adc.h fsl_adc_etc.h fsl_aipstz.h fsl_aoi.h fsl_bee.h fsl_cache.h fsl_clock.h fsl_cmp.h fsl_common.h fsl_common_arm.h fsl_csi.h fsl_dcdc.h fsl_dcp.h fsl_dmamux.h fsl_edma.h fsl_elcdif.h fsl_enc.h fsl_enet.h fsl_ewm.h fsl_flexcan.h fsl_flexcan_edma.h fsl_flexio.h fsl_flexio_camera.h fsl_flexio_camera_edma.h fsl_flexio_i2c_master.h fsl_flexio_i2s.h fsl_flexio_i2s_edma.h fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.h fsl_flexio_spi.h fsl_flexio_spi_edma.h fsl_flexio_uart.h fsl_flexio_uart_edma.h fsl_flexram.h fsl_flexram_allocate.h fsl_flexspi.h fsl_flexspi_edma.h fsl_gpc.h fsl_gpio.h fsl_gpt.h fsl_iomuxc.h fsl_kpp.h fsl_lpi2c.h fsl_lpi2c_edma.h fsl_lpspi.h fsl_lpspi_edma.h fsl_lpuart.h fsl_lpuart_edma.h fsl_nic301.h fsl_ocotp.h fsl_pit.h fsl_pmu.h fsl_pwm.h fsl_pxp.h fsl_qtmr.h fsl_romapi.h fsl_rtwdog.h fsl_sai.h fsl_sai_edma.h fsl_semc.h fsl_snvs_hp.h fsl_snvs_lp.h fsl_spdif.h fsl_spdif_edma.h fsl_src.h fsl_tempmon.h fsl_trng.h fsl_tsc.h fsl_usdhc.h fsl_wdog.h fsl_xbara.h fsl_xbarb.h
  group sdk_device
    ../../Libraries/sdk/board/: board.c board.h clock_config.c clock_config.h
    ../../Libraries/sdk/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h
    ../../Libraries/sdk/deceive/: system_MIMXRT1064.c system_MIMXRT1064.h MIMXRT1064_features.h MIMXRT1064.h fsl_device_registers.h
    ../../Libraries/sdk/utilities/: fsl_assert.c
    ../../Libraries/sdk/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../../Libraries/sdk/utilities/debug_console/: fsl_debug_console_conf.h fsl_debug_console.c fsl_debug_console.h
    ../../Libraries/sdk/components/lists/: fsl_component_generic_list.c
    ../../Libraries/sdk/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
    ../../libraries/sdk/startup/mdk/: startup_MIMXRT1064.S
  group components_fatfs
    ../../Libraries/components/fatfs/source/: ff.c ffsystem.c ffunicode.c diskio.c
    ../../Libraries/components/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
  group components_sdmmc
    ../../Libraries/components/sdmmc/: sdmmc_config.c
    ../../Libraries/components/sdmmc/common/: fsl_sdmmc_common.c
    ../../Libraries/components/sdmmc/host/usdhc/blocking/: fsl_sdmmc_host.c
    ../../Libraries/components/sdmmc/osa/: fsl_sdmmc_osa.c
    ../../Libraries/components/sdmmc/sd/: fsl_sd.c
  group components_usb
    ../../Libraries/components/usb/device/: usb_device_ehci.c usb_device_dci.c usb_device.h usb_device_dci.h usb_device_ehci.h
    ../../Libraries/components/usb/phy/: usb_phy.c usb_phy.h
    ../../Libraries/components/usb/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_ch9.c usb_device_class.c usb_device_descriptor.c usb_device_cdc_acm.h usb_device_descriptor.h
    ../../Libraries/components/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../Libraries/components/usb/templates/config/: usb_device_config.h
    ../../Libraries/components/usb/templates/device/: usb_device_ch9.h
    ../../Libraries/components/usb/templates/device/class/: usb_device_class.h
